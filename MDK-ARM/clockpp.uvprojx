# Keil uVision project clockpp.uvprojx, settings and files
target clockpp (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: clockpp +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx  LV_CONF_INCLUDE_SIMPLE  LV_LVGL_H_INCLUDE_SIMPLE,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./bsp_posting;./bsp_wrapper;./bsp_driver;../Middlewares/Third_Party/Lvgl;../Middlewares/Third_Party/Lvgl/demos;../Middlewares/Third_Party/Lvgl/posting;../Middlewares/Third_Party/Lvgl/src;../Middlewares/Third_Party/LetterShell;../Service/LetterShell;../Middlewares/Third_Party/OSAL;../Middlewares/Third_Party/CJSON;../Service/Network;..\App\UI;..\App\Message_Pump;..\App\System;..\Middlewares\Third_Party\EasyLogger\inc
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App/System
    ../App/System/: app_startingup.c
  group App/UI
    ../App/UI/: app_ui_controller.c app_ui_engine.c app_ui_views.c
  group App/Message_Pump
    ../App/Message_Pump/: app_event_bus.c
  group Service/Network
    ../Service/Network/: service_network.c service_network_hub.c
  group Service/LetterShell
    ../Service/LetterShell/: service_lettershell.c
  group Middlewares/Easylogger
    ../Middlewares/Third_Party/EasyLogger/port/: elog_port.c
    ../Middlewares/Third_Party/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Middlewares/CJSON
    ../Middlewares/Third_Party/CJSON/: cJSON.c cJSON_port.c
  group Middlewares/Osal
    ../Middlewares/Third_Party/OSAL/: osal_freertos.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Third_Party/Lvgl/posting
    ../Middlewares/Third_Party/Lvgl/posting/: lv_port_indev.c lv_port_disp.c
  group Middlewares/Lvgl
    ../Middlewares/Third_Party/Lvgl/: lv_conf.h lv_port_disp.h lv_port_indev.h lv_version.h lvgl.h lvgl_private.h
  group Middlewares/LetterShell
    ../Middlewares/Third_Party/LetterShell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group bsp/wrapper
    ./bsp_wrapper/: display_wrapper.c touch_wrapper.c network_uart_wrapper.c rtc_wrapper.c uart1_wrapper.c
  group bsp/posting
    ./bsp_posting/: display_posting.c touch_posting.c esp32_uart_posting.c rtc_posting.c uart1_posting.c
  group bsp/driver
    ./bsp_driver/: st7789.c ft6336.c ringbuffer.c esp32_uart_driver.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/Third_Party/Lvgl/demos/benchmark/assets
    ../Middlewares/Third_Party/Lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
  group Middlewares/Third_Party/Lvgl/demos/benchmark
    ../Middlewares/Third_Party/Lvgl/demos/benchmark/: lv_demo_benchmark.c
  group Middlewares/Third_Party/Lvgl/demos/gltf
    ../Middlewares/Third_Party/Lvgl/demos/gltf/: lv_demo_gltf.c
  group Middlewares/Third_Party/Lvgl/demos/keypad_encoder
    ../Middlewares/Third_Party/Lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group Middlewares/Third_Party/Lvgl/demos
    ../Middlewares/Third_Party/Lvgl/demos/: lv_demos.c
  group Middlewares/Third_Party/Lvgl/demos/music/assets
    ../Middlewares/Third_Party/Lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group Middlewares/Third_Party/Lvgl/demos/music
    ../Middlewares/Third_Party/Lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group Middlewares/Third_Party/Lvgl/demos/render/assets
    ../Middlewares/Third_Party/Lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_argb8888_premultiplied.c img_render_lvgl_logo_i1.c img_render_lvgl_logo_l8.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb565a8.c img_render_lvgl_logo_rgb565_swapped.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
  group Middlewares/Third_Party/Lvgl/demos/render
    ../Middlewares/Third_Party/Lvgl/demos/render/: lv_demo_render.c
  group Middlewares/Third_Party/Lvgl/demos/stress
    ../Middlewares/Third_Party/Lvgl/demos/stress/: lv_demo_stress.c
  group Middlewares/Third_Party/Lvgl/demos/vector_graphic/assets
    ../Middlewares/Third_Party/Lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
  group Middlewares/Third_Party/Lvgl/demos/vector_graphic
    ../Middlewares/Third_Party/Lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
  group Middlewares/Third_Party/Lvgl/demos/widgets/assets
    ../Middlewares/Third_Party/Lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group Middlewares/Third_Party/Lvgl/demos/widgets
    ../Middlewares/Third_Party/Lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
  group Middlewares/Third_Party/Lvgl/src/core
    ../Middlewares/Third_Party/Lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group Middlewares/Third_Party/Lvgl/src/debugging/monkey
    ../Middlewares/Third_Party/Lvgl/src/debugging/monkey/: lv_monkey.c
  group Middlewares/Third_Party/Lvgl/src/debugging/sysmon
    ../Middlewares/Third_Party/Lvgl/src/debugging/sysmon/: lv_sysmon.c
  group Middlewares/Third_Party/Lvgl/src/debugging/test
    ../Middlewares/Third_Party/Lvgl/src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
  group Middlewares/Third_Party/Lvgl/src/debugging/vg_lite_tvg
    ../Middlewares/Third_Party/Lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c vg_lite_tvg.cpp
  group Middlewares/Third_Party/Lvgl/src/display
    ../Middlewares/Third_Party/Lvgl/src/display/: lv_display.c
  group Middlewares/Third_Party/Lvgl/src/draw/convert/helium
    ../Middlewares/Third_Party/Lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
  group Middlewares/Third_Party/Lvgl/src/draw/convert
    ../Middlewares/Third_Party/Lvgl/src/draw/convert/: lv_draw_buf_convert.c
  group Middlewares/Third_Party/Lvgl/src/draw/convert/neon
    ../Middlewares/Third_Party/Lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
  group Middlewares/Third_Party/Lvgl/src/draw/dma2d
    ../Middlewares/Third_Party/Lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
  group Middlewares/Third_Party/Lvgl/src/draw/espressif/ppa
    ../Middlewares/Third_Party/Lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
  group Middlewares/Third_Party/Lvgl/src/draw/eve
    ../Middlewares/Third_Party/Lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
  group Middlewares/Third_Party/Lvgl/src/draw
    ../Middlewares/Third_Party/Lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group Middlewares/Third_Party/Lvgl/src/draw/nanovg
    ../Middlewares/Third_Party/Lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
  group Middlewares/Third_Party/Lvgl/src/draw/nema_gfx
    ../Middlewares/Third_Party/Lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
  group Middlewares/Third_Party/Lvgl/src/draw/nxp/g2d
    ../Middlewares/Third_Party/Lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
  group Middlewares/Third_Party/Lvgl/src/draw/nxp/pxp
    ../Middlewares/Third_Party/Lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
  group Middlewares/Third_Party/Lvgl/src/draw/opengles
    ../Middlewares/Third_Party/Lvgl/src/draw/opengles/: lv_draw_opengles.c
  group Middlewares/Third_Party/Lvgl/src/draw/renesas/dave2d
    ../Middlewares/Third_Party/Lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
  group Middlewares/Third_Party/Lvgl/src/draw/sdl
    ../Middlewares/Third_Party/Lvgl/src/draw/sdl/: lv_draw_sdl.c
  group Middlewares/Third_Party/Lvgl/src/draw/snapshot
    ../Middlewares/Third_Party/Lvgl/src/draw/snapshot/: lv_snapshot.c
  group Middlewares/Third_Party/Lvgl/src/draw/sw/blend
    ../Middlewares/Third_Party/Lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group Middlewares/Third_Party/Lvgl/src/draw/sw/blend/neon
    ../Middlewares/Third_Party/Lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
  group Middlewares/Third_Party/Lvgl/src/draw/sw/blend/riscv_v
    ../Middlewares/Third_Party/Lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
  group Middlewares/Third_Party/Lvgl/src/draw/sw
    ../Middlewares/Third_Party/Lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group Middlewares/Third_Party/Lvgl/src/draw/vg_lite
    ../Middlewares/Third_Party/Lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/drm
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/fb
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/ft81x
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/ft81x/: lv_ft81x.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/ili9341
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/ili9341/: lv_ili9341.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/lcd
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/lovyan_gfx
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/lovyan_gfx/: lv_lovyan_gfx.cpp
  group Middlewares/Third_Party/Lvgl/src/drivers/display/nv3007
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/nv3007/: lv_nv3007.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/nxp_elcdif
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/renesas_glcdc
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/st7735
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/st7735/: lv_st7735.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/st7789
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/st7789/: lv_st7789.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/st7796
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/st7796/: lv_st7796.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/st_ltdc
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
  group Middlewares/Third_Party/Lvgl/src/drivers/display/tft_espi
    ../Middlewares/Third_Party/Lvgl/src/drivers/display/tft_espi/: lv_tft_espi.cpp
  group Middlewares/Third_Party/Lvgl/src/drivers/draw/eve
    ../Middlewares/Third_Party/Lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
  group Middlewares/Third_Party/Lvgl/src/drivers/evdev
    ../Middlewares/Third_Party/Lvgl/src/drivers/evdev/: lv_evdev.c
  group Middlewares/Third_Party/Lvgl/src/drivers/libinput
    ../Middlewares/Third_Party/Lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
  group Middlewares/Third_Party/Lvgl/src/drivers/nuttx
    ../Middlewares/Third_Party/Lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
  group Middlewares/Third_Party/Lvgl/src/drivers/opengles/assets
    ../Middlewares/Third_Party/Lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
  group Middlewares/Third_Party/Lvgl/src/drivers/opengles/glad/src
    ../Middlewares/Third_Party/Lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
  group Middlewares/Third_Party/Lvgl/src/drivers/opengles
    ../Middlewares/Third_Party/Lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
  group Middlewares/Third_Party/Lvgl/src/drivers/opengles/opengl_shader
    ../Middlewares/Third_Party/Lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
  group Middlewares/Third_Party/Lvgl/src/drivers/qnx
    ../Middlewares/Third_Party/Lvgl/src/drivers/qnx/: lv_qnx.c
  group Middlewares/Third_Party/Lvgl/src/drivers/sdl
    ../Middlewares/Third_Party/Lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
  group Middlewares/Third_Party/Lvgl/src/drivers/uefi
    ../Middlewares/Third_Party/Lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
  group Middlewares/Third_Party/Lvgl/src/drivers/wayland
    ../Middlewares/Third_Party/Lvgl/src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
  group Middlewares/Third_Party/Lvgl/src/drivers/windows
    ../Middlewares/Third_Party/Lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
  group Middlewares/Third_Party/Lvgl/src/drivers/x11
    ../Middlewares/Third_Party/Lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group Middlewares/Third_Party/Lvgl/src/font/binfont_loader
    ../Middlewares/Third_Party/Lvgl/src/font/binfont_loader/: lv_binfont_loader.c
  group Middlewares/Third_Party/Lvgl/src/font/fmt_txt
    ../Middlewares/Third_Party/Lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
  group Middlewares/Third_Party/Lvgl/src/font/font_manager
    ../Middlewares/Third_Party/Lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
  group Middlewares/Third_Party/Lvgl/src/font/imgfont
    ../Middlewares/Third_Party/Lvgl/src/font/imgfont/: lv_imgfont.c
  group Middlewares/Third_Party/Lvgl/src/font
    ../Middlewares/Third_Party/Lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Middlewares/Third_Party/Lvgl/src/indev
    ../Middlewares/Third_Party/Lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group Middlewares/Third_Party/Lvgl/src/layouts/flex
    ../Middlewares/Third_Party/Lvgl/src/layouts/flex/: lv_flex.c
  group Middlewares/Third_Party/Lvgl/src/layouts/grid
    ../Middlewares/Third_Party/Lvgl/src/layouts/grid/: lv_grid.c
  group Middlewares/Third_Party/Lvgl/src/layouts
    ../Middlewares/Third_Party/Lvgl/src/layouts/: lv_layout.c
  group Middlewares/Third_Party/Lvgl/src/libs/barcode
    ../Middlewares/Third_Party/Lvgl/src/libs/barcode/: code128.c lv_barcode.c
  group Middlewares/Third_Party/Lvgl/src/libs/bin_decoder
    ../Middlewares/Third_Party/Lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group Middlewares/Third_Party/Lvgl/src/libs/bmp
    ../Middlewares/Third_Party/Lvgl/src/libs/bmp/: lv_bmp.c
  group Middlewares/Third_Party/Lvgl/src/libs/ffmpeg
    ../Middlewares/Third_Party/Lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
  group Middlewares/Third_Party/Lvgl/src/libs/freetype
    ../Middlewares/Third_Party/Lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
  group Middlewares/Third_Party/Lvgl/src/libs/frogfs/src
    ../Middlewares/Third_Party/Lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
  group Middlewares/Third_Party/Lvgl/src/libs/fsdrv
    ../Middlewares/Third_Party/Lvgl/src/libs/fsdrv/: lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
  group Middlewares/Third_Party/Lvgl/src/libs/FT800-FT813
    ../Middlewares/Third_Party/Lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
  group Middlewares/Third_Party/Lvgl/src/libs/gif
    ../Middlewares/Third_Party/Lvgl/src/libs/gif/: gif.c
  group Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_data
    ../Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_data/: lv_gltf_data.cpp lv_gltf_data_animations.cpp lv_gltf_data_cache.cpp lv_gltf_data_injest.cpp lv_gltf_data_mesh.cpp lv_gltf_data_primitive.cpp lv_gltf_data_shader.cpp lv_gltf_data_skin.cpp lv_gltf_data_texture.cpp lv_gltf_model_node.cpp lv_gltf_uniform_locations.cpp
  group Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_environment
    ../Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
  group Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_view/assets
    ../Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
  group Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_view
    ../Middlewares/Third_Party/Lvgl/src/libs/gltf/gltf_view/: lv_gltf_view.cpp lv_gltf_view_render.cpp lv_gltf_view_shader.cpp
  group Middlewares/Third_Party/Lvgl/src/libs/gltf/math
    ../Middlewares/Third_Party/Lvgl/src/libs/gltf/math/: lv_3dmath.c lv_gltf_math.cpp
  group Middlewares/Third_Party/Lvgl/src/libs/gstreamer
    ../Middlewares/Third_Party/Lvgl/src/libs/gstreamer/: lv_gstreamer.c
  group Middlewares/Third_Party/Lvgl/src/libs/libjpeg_turbo
    ../Middlewares/Third_Party/Lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group Middlewares/Third_Party/Lvgl/src/libs/libpng
    ../Middlewares/Third_Party/Lvgl/src/libs/libpng/: lv_libpng.c
  group Middlewares/Third_Party/Lvgl/src/libs/libwebp
    ../Middlewares/Third_Party/Lvgl/src/libs/libwebp/: lv_libwebp.c
  group Middlewares/Third_Party/Lvgl/src/libs/lodepng
    ../Middlewares/Third_Party/Lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
  group Middlewares/Third_Party/Lvgl/src/libs/lz4
    ../Middlewares/Third_Party/Lvgl/src/libs/lz4/: lz4.c
  group Middlewares/Third_Party/Lvgl/src/libs/nanovg
    ../Middlewares/Third_Party/Lvgl/src/libs/nanovg/: nanovg.c
  group Middlewares/Third_Party/Lvgl/src/libs/qrcode
    ../Middlewares/Third_Party/Lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group Middlewares/Third_Party/Lvgl/src/libs/rle
    ../Middlewares/Third_Party/Lvgl/src/libs/rle/: lv_rle.c
  group Middlewares/Third_Party/Lvgl/src/libs/rlottie
    ../Middlewares/Third_Party/Lvgl/src/libs/rlottie/: lv_rlottie.c
  group Middlewares/Third_Party/Lvgl/src/libs/svg
    ../Middlewares/Third_Party/Lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
  group Middlewares/Third_Party/Lvgl/src/libs/thorvg
    ../Middlewares/Third_Party/Lvgl/src/libs/thorvg/: tvgAccessor.cpp tvgAnimation.cpp tvgCanvas.cpp tvgCapi.cpp tvgCompressor.cpp tvgFill.cpp tvgGlCanvas.cpp tvgInitializer.cpp tvgLoader.cpp tvgLottieAnimation.cpp tvgLottieBuilder.cpp tvgLottieExpressions.cpp tvgLottieInterpolator.cpp tvgLottieLoader.cpp tvgLottieModel.cpp tvgLottieModifier.cpp tvgLottieParser.cpp tvgLottieParserHandler.cpp tvgMath.cpp tvgPaint.cpp tvgPicture.cpp tvgRawLoader.cpp tvgRender.cpp tvgSaver.cpp tvgScene.cpp tvgShape.cpp tvgStr.cpp tvgSvgCssStyle.cpp tvgSvgLoader.cpp tvgSvgPath.cpp tvgSvgSceneBuilder.cpp tvgSvgUtil.cpp tvgSwCanvas.cpp tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwPostEffect.cpp tvgSwRaster.cpp tvgSwRenderer.cpp tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgText.cpp tvgWgCanvas.cpp tvgXmlParser.cpp
  group Middlewares/Third_Party/Lvgl/src/libs/tiny_ttf
    ../Middlewares/Third_Party/Lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group Middlewares/Third_Party/Lvgl/src/libs/tjpgd
    ../Middlewares/Third_Party/Lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group Middlewares/Third_Party/Lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal
    ../Middlewares/Third_Party/Lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
  group Middlewares/Third_Party/Lvgl/src/libs/vg_lite_driver/VGLite
    ../Middlewares/Third_Party/Lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
  group Middlewares/Third_Party/Lvgl/src/libs/vg_lite_driver/VGLiteKernel
    ../Middlewares/Third_Party/Lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
  group Middlewares/Third_Party/Lvgl/src
    ../Middlewares/Third_Party/Lvgl/src/: lv_init.c
  group Middlewares/Third_Party/Lvgl/src/misc/cache/class
    ../Middlewares/Third_Party/Lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
  group Middlewares/Third_Party/Lvgl/src/misc/cache/instance
    ../Middlewares/Third_Party/Lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group Middlewares/Third_Party/Lvgl/src/misc/cache
    ../Middlewares/Third_Party/Lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
  group Middlewares/Third_Party/Lvgl/src/misc
    ../Middlewares/Third_Party/Lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group Middlewares/Third_Party/Lvgl/src/osal
    ../Middlewares/Third_Party/Lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group Middlewares/Third_Party/Lvgl/src/others/file_explorer
    ../Middlewares/Third_Party/Lvgl/src/others/file_explorer/: lv_file_explorer.c
  group Middlewares/Third_Party/Lvgl/src/others/fragment
    ../Middlewares/Third_Party/Lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group Middlewares/Third_Party/Lvgl/src/others/translation
    ../Middlewares/Third_Party/Lvgl/src/others/translation/: lv_translation.c
  group Middlewares/Third_Party/Lvgl/src/stdlib/builtin
    ../Middlewares/Third_Party/Lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group Middlewares/Third_Party/Lvgl/src/stdlib/clib
    ../Middlewares/Third_Party/Lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group Middlewares/Third_Party/Lvgl/src/stdlib
    ../Middlewares/Third_Party/Lvgl/src/stdlib/: lv_mem.c
  group Middlewares/Third_Party/Lvgl/src/stdlib/micropython
    ../Middlewares/Third_Party/Lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group Middlewares/Third_Party/Lvgl/src/stdlib/rtthread
    ../Middlewares/Third_Party/Lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group Middlewares/Third_Party/Lvgl/src/stdlib/uefi
    ../Middlewares/Third_Party/Lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group Middlewares/Third_Party/Lvgl/src/themes/default
    ../Middlewares/Third_Party/Lvgl/src/themes/default/: lv_theme_default.c
  group Middlewares/Third_Party/Lvgl/src/themes
    ../Middlewares/Third_Party/Lvgl/src/themes/: lv_theme.c
  group Middlewares/Third_Party/Lvgl/src/themes/mono
    ../Middlewares/Third_Party/Lvgl/src/themes/mono/: lv_theme_mono.c
  group Middlewares/Third_Party/Lvgl/src/themes/simple
    ../Middlewares/Third_Party/Lvgl/src/themes/simple/: lv_theme_simple.c
  group Middlewares/Third_Party/Lvgl/src/tick
    ../Middlewares/Third_Party/Lvgl/src/tick/: lv_tick.c
  group Middlewares/Third_Party/Lvgl/src/widgets/3dtexture
    ../Middlewares/Third_Party/Lvgl/src/widgets/3dtexture/: lv_3dtexture.c
  group Middlewares/Third_Party/Lvgl/src/widgets/animimage
    ../Middlewares/Third_Party/Lvgl/src/widgets/animimage/: lv_animimage.c
  group Middlewares/Third_Party/Lvgl/src/widgets/arc
    ../Middlewares/Third_Party/Lvgl/src/widgets/arc/: lv_arc.c
  group Middlewares/Third_Party/Lvgl/src/widgets/arclabel
    ../Middlewares/Third_Party/Lvgl/src/widgets/arclabel/: lv_arclabel.c
  group Middlewares/Third_Party/Lvgl/src/widgets/bar
    ../Middlewares/Third_Party/Lvgl/src/widgets/bar/: lv_bar.c
  group Middlewares/Third_Party/Lvgl/src/widgets/button
    ../Middlewares/Third_Party/Lvgl/src/widgets/button/: lv_button.c
  group Middlewares/Third_Party/Lvgl/src/widgets/buttonmatrix
    ../Middlewares/Third_Party/Lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group Middlewares/Third_Party/Lvgl/src/widgets/calendar
    ../Middlewares/Third_Party/Lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group Middlewares/Third_Party/Lvgl/src/widgets/canvas
    ../Middlewares/Third_Party/Lvgl/src/widgets/canvas/: lv_canvas.c
  group Middlewares/Third_Party/Lvgl/src/widgets/chart
    ../Middlewares/Third_Party/Lvgl/src/widgets/chart/: lv_chart.c
  group Middlewares/Third_Party/Lvgl/src/widgets/checkbox
    ../Middlewares/Third_Party/Lvgl/src/widgets/checkbox/: lv_checkbox.c
  group Middlewares/Third_Party/Lvgl/src/widgets/dropdown
    ../Middlewares/Third_Party/Lvgl/src/widgets/dropdown/: lv_dropdown.c
  group Middlewares/Third_Party/Lvgl/src/widgets/gif
    ../Middlewares/Third_Party/Lvgl/src/widgets/gif/: lv_gif.c
  group Middlewares/Third_Party/Lvgl/src/widgets/image
    ../Middlewares/Third_Party/Lvgl/src/widgets/image/: lv_image.c
  group Middlewares/Third_Party/Lvgl/src/widgets/imagebutton
    ../Middlewares/Third_Party/Lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group Middlewares/Third_Party/Lvgl/src/widgets/ime
    ../Middlewares/Third_Party/Lvgl/src/widgets/ime/: lv_ime_pinyin.c
  group Middlewares/Third_Party/Lvgl/src/widgets/keyboard
    ../Middlewares/Third_Party/Lvgl/src/widgets/keyboard/: lv_keyboard.c
  group Middlewares/Third_Party/Lvgl/src/widgets/label
    ../Middlewares/Third_Party/Lvgl/src/widgets/label/: lv_label.c
  group Middlewares/Third_Party/Lvgl/src/widgets/led
    ../Middlewares/Third_Party/Lvgl/src/widgets/led/: lv_led.c
  group Middlewares/Third_Party/Lvgl/src/widgets/line
    ../Middlewares/Third_Party/Lvgl/src/widgets/line/: lv_line.c
  group Middlewares/Third_Party/Lvgl/src/widgets/list
    ../Middlewares/Third_Party/Lvgl/src/widgets/list/: lv_list.c
  group Middlewares/Third_Party/Lvgl/src/widgets/lottie
    ../Middlewares/Third_Party/Lvgl/src/widgets/lottie/: lv_lottie.c
  group Middlewares/Third_Party/Lvgl/src/widgets/menu
    ../Middlewares/Third_Party/Lvgl/src/widgets/menu/: lv_menu.c
  group Middlewares/Third_Party/Lvgl/src/widgets/msgbox
    ../Middlewares/Third_Party/Lvgl/src/widgets/msgbox/: lv_msgbox.c
  group Middlewares/Third_Party/Lvgl/src/widgets/objx_templ
    ../Middlewares/Third_Party/Lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group Middlewares/Third_Party/Lvgl/src/widgets/property
    ../Middlewares/Third_Party/Lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
  group Middlewares/Third_Party/Lvgl/src/widgets/roller
    ../Middlewares/Third_Party/Lvgl/src/widgets/roller/: lv_roller.c
  group Middlewares/Third_Party/Lvgl/src/widgets/scale
    ../Middlewares/Third_Party/Lvgl/src/widgets/scale/: lv_scale.c
  group Middlewares/Third_Party/Lvgl/src/widgets/slider
    ../Middlewares/Third_Party/Lvgl/src/widgets/slider/: lv_slider.c
  group Middlewares/Third_Party/Lvgl/src/widgets/span
    ../Middlewares/Third_Party/Lvgl/src/widgets/span/: lv_span.c
  group Middlewares/Third_Party/Lvgl/src/widgets/spinbox
    ../Middlewares/Third_Party/Lvgl/src/widgets/spinbox/: lv_spinbox.c
  group Middlewares/Third_Party/Lvgl/src/widgets/spinner
    ../Middlewares/Third_Party/Lvgl/src/widgets/spinner/: lv_spinner.c
  group Middlewares/Third_Party/Lvgl/src/widgets/switch
    ../Middlewares/Third_Party/Lvgl/src/widgets/switch/: lv_switch.c
  group Middlewares/Third_Party/Lvgl/src/widgets/table
    ../Middlewares/Third_Party/Lvgl/src/widgets/table/: lv_table.c
  group Middlewares/Third_Party/Lvgl/src/widgets/tabview
    ../Middlewares/Third_Party/Lvgl/src/widgets/tabview/: lv_tabview.c
  group Middlewares/Third_Party/Lvgl/src/widgets/textarea
    ../Middlewares/Third_Party/Lvgl/src/widgets/textarea/: lv_textarea.c
  group Middlewares/Third_Party/Lvgl/src/widgets/tileview
    ../Middlewares/Third_Party/Lvgl/src/widgets/tileview/: lv_tileview.c
  group Middlewares/Third_Party/Lvgl/src/widgets/win
    ../Middlewares/Third_Party/Lvgl/src/widgets/win/: lv_win.c
software components: CMSIS:CORE 4.3.0
